<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fhss_detector_reference</value></param>
<param><key>author</key><value>J. Gilbert</value></param>
<param><key>description</key><value>Reference Application</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Burst Detector Reference</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>2000e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, 1, output_cutoff/decimation, output_trans_width/decimation, output_attenuation)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fir_taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, 1, 0.5*output_cutoff, 0.5*output_trans_width, output_attenuation)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>70</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>6</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/tmp/samples.sc16</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>pow(2,-15) * pow(2,(s0_gain/10))</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>1024000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>burst_width</value></param>
<param><key>label</key><value>Burst Width [Hz]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(500e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_start_offset</value></param>
<param><key>label</key><value>CFO Start Offset [s]</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_threshold</value></param>
<param><key>label</key><value>CFO threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_time_to_average</value></param>
<param><key>label</key><value>CFO Average Time [s]</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimation</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>fhss_utils_fft_burst_tagger</key>
<param><key>id</key><value>fhss_utils_fft_burst_tagger_0</value></param>
<param><key>burst_width</key><value>burst_width</value></param>
<param><key>center_frequency</key><value>center_freq</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>history_size</key><value>int(round((float(samp_rate)/fft_size)*hist_time))</value></param>
<param><key>lookahead</key><value>int(round((float(samp_rate)/fft_size)*lookahead_time))</value></param>
<param><key>max_burst_len</key><value>0</value></param>
<param><key>max_bursts</key><value>0</value></param>
<param><key>minoutbuf</key><value>2048*1000</value></param>
<param><key>burst_post_len</key><value>int(round((float(samp_rate)/fft_size)*post_burst_time))</value></param>
<param><key>burst_pre_len</key><value>int(round((float(samp_rate)/fft_size)*pre_burst_time))</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>fhss_utils_fine_burst_measure</key>
<param><key>id</key><value>fhss_utils_fine_burst_measure_0</value></param>
<param><key>samples</key><value>2048</value></param>
<param><key>freq_resolution</key><value>4000</value></param>
<param><key>threshold</key><value>0.5</value></param>
</block>
<block>
<key>fhss_utils_pdu_quadrature_demod_cf</key>
<param><key>id</key><value>fhss_utils_pdu_quadrature_demod_cf_0</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>fhss_utils_tagged_burst_to_pdu</key>
<param><key>id</key><value>fhss_utils_tagged_burst_to_pdu_0</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>taps</key><value>decim_taps</value></param>
<param><key>max_burst_time</key><value>max_burst_time</value></param>
<param><key>min_burst_time</key><value>min_burst_time</value></param>
<param><key>threads</key><value>7</value></param>
<param><key>relative_center_frequency</key><value>0.0</value></param>
<param><key>relative_sample_rate</key><value>1.0</value></param>
<param><key>relative_span</key><value>1.0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>fsk_burst_extractor_hier</key>
<param><key>id</key><value>fsk_burst_extractor_hier_0</value></param>
<param><key>burst_width</key><value>int(500e3)</value></param>
<param><key>cfo_bin_resolution</key><value>10000</value></param>
<param><key>cfo_samps_to_average</key><value>2048</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>hist_time</key><value>0.004</value></param>
<param><key>lookahead_time</key><value>0.0005</value></param>
<param><key>max_burst_time</key><value>0.5</value></param>
<param><key>min_burst_time</key><value>0.001</value></param>
<param><key>output_attenuation</key><value>40</value></param>
<param><key>output_cutoff</key><value>0.45</value></param>
<param><key>output_trans_width</key><value>0.05</value></param>
<param><key>post_burst_time</key><value>0.00015</value></param>
<param><key>pre_burst_time</key><value>0.00015</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hist_time</value></param>
<param><key>label</key><value>History Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.004</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lookahead_time</value></param>
<param><key>label</key><value>Lookahead Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_burst_time</value></param>
<param><key>label</key><value>Max Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>min_burst_time</value></param>
<param><key>label</key><value>Min Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>.                                                                                                                                                                                                                                  Burst Detection
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>comment</key><value>.                                                                                                                                                                                                                                  Tuning Parameters
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>comment</key><value>.                                                                                                                                                                                                                                  Input
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>comment</key><value>.                                                                                                                                                                                                                                  FM Demodulation
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_attenuation</value></param>
<param><key>label</key><value>Output Attenuation</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_cutoff</value></param>
<param><key>label</key><value>Output Cutoff [cycles/samp]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_trans_width</value></param>
<param><key>label</key><value>Output Trans. Width [cycles/samp]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>pdu_utils_pdu_clock_recovery</key>
<param><key>id</key><value>pdu_utils_pdu_clock_recovery_0</value></param>
<param><key>binary_slice</key><value>none</value></param>
</block>
<block>
<key>pdu_utils_pdu_clock_recovery</key>
<param><key>id</key><value>pdu_utils_pdu_clock_recovery_0_0</value></param>
<param><key>binary_slice</key><value>binary</value></param>
</block>
<block>
<key>pdu_utils_pdu_fine_time_measure</key>
<param><key>id</key><value>pdu_utils_pdu_fine_time_measure_0</value></param>
<param><key>buffer_percent</key><value>15</value></param>
<param><key>average_width</key><value>10</value></param>
<param><key>post_burst_time</key><value>post_burst_time</value></param>
<param><key>pre_burst_time</key><value>pre_burst_time</value></param>
</block>
<block>
<key>pdu_utils_pdu_fir_filter</key>
<param><key>id</key><value>pdu_utils_pdu_fir_filter_1</value></param>
<param><key>decimation</key><value>2</value></param>
<param><key>taps</key><value>fir_taps</value></param>
</block>
<block>
<key>pdu_utils_pdu_split</key>
<param><key>id</key><value>pdu_utils_pdu_split_0_0</value></param>
<param><key>pass_empty</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>post_burst_time</value></param>
<param><key>label</key><value>Post Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.00008</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_burst_time</value></param>
<param><key>label</key><value>Pre Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.00008</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"FM Demodulation"</value></param>
<param><key>size</key><value>102400</value></param>
<param><key>srate</key><value>samp_rate/decimation</value></param>
<param><key>tr_delay</key><value>.001</value></param>
<param><key>tr_level</key><value>0.000001</value></param>
<param><key>type</key><value>msg_float</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0_0_0_0</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"black"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>name</key><value>"Soft Symbols"</value></param>
<param><key>size</key><value>102400</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>tr_delay</key><value>.001</value></param>
<param><key>tr_level</key><value>0.000001</value></param>
<param><key>type</key><value>msg_float</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decimation/2</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>128</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>name</key><value>"Burst Spectrogram"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>update_time</key><value>0.005</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>int_min</key><value>-120</value></param>
<param><key>name</key><value>"Input Spectrogram"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(30.72e6)</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>minoutbuf</key><value>2048*1000</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>bursts</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>symbols</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2</value></param>
<param><key>stream_id</key><value>bursts</value></param>
</block>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fhss_utils_fft_burst_tagger_0</source_block_id><sink_block_id>fhss_utils_tagged_burst_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fhss_utils_fine_burst_measure_0</source_block_id><sink_block_id>pdu_utils_pdu_fir_filter_1</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>fhss_utils_pdu_quadrature_demod_cf_0</source_block_id><sink_block_id>pdu_utils_pdu_clock_recovery_0</sink_block_id><source_key>fpdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>fhss_utils_pdu_quadrature_demod_cf_0</source_block_id><sink_block_id>pdu_utils_pdu_clock_recovery_0_0</sink_block_id><source_key>fpdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>fhss_utils_pdu_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>fpdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fhss_utils_tagged_burst_to_pdu_0</source_block_id><sink_block_id>fhss_utils_fine_burst_measure_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>fsk_burst_extractor_hier_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_clock_recovery_0</source_block_id><sink_block_id>pdu_utils_pdu_split_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_clock_recovery_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0_0_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_clock_recovery_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_fine_time_measure_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_fir_filter_1</source_block_id><sink_block_id>pdu_utils_pdu_fine_time_measure_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_split_0_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>dict</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>fhss_utils_fft_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>fsk_burst_extractor_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>fhss_utils_pdu_quadrature_demod_cf_0</sink_block_id><source_key>out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>

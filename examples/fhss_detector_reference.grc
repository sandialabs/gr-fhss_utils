options:
  parameters:
    author: J. Gilbert
    description: Reference Application
    generate_options: qt_gui
    id: fhss_detector_reference
    output_language: python
    title: Burst Detector Reference
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Center Frequency
    orient: Qt.Horizontal
    start: 100e6
    step: 1e6
    stop: 2000e6
    value: 915e6
  states: {}
- name: decim_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, output_cutoff/decimation, output_trans_width/decimation, output_attenuation)
  states: {}
- name: fir_taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, 1, 0.5*output_cutoff, 0.5*output_trans_width, output_attenuation)
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '40'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: Threshold
    orient: Qt.Horizontal
    start: '6'
    step: '1'
    stop: '25'
    value: '10'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /tmp/samples.sc16
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0_1
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pow(2,-15) * pow(2,(s0_gain/10))
    minoutbuf: '1024000'
    type: complex
  states: {state: disabled}
- name: burst_width
  id: parameter
  parameters:
    hide: part
    label: Burst Width [Hz]
    type: intx
    value: int(500e3)
  states: {}
- name: cfo_start_offset
  id: parameter
  parameters:
    label: CFO Start Offset [s]
    type: eng_float
    value: '0'
  states: {}
- name: cfo_threshold
  id: parameter
  parameters:
    label: CFO threshold
    type: eng_float
    value: '0.5'
  states: {}
- name: cfo_time_to_average
  id: parameter
  parameters:
    label: CFO Average Time [s]
    type: eng_float
    value: '0.0005'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '32'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    type: intx
    value: '256'
  states: {}
- name: fhss_utils_fft_burst_tagger_0
  id: fhss_utils_fft_burst_tagger
  parameters:
    burst_post_len: int(round((float(samp_rate)/fft_size)*post_burst_time))
    burst_pre_len: int(round((float(samp_rate)/fft_size)*pre_burst_time))
    burst_width: burst_width
    center_frequency: center_freq
    debug: 'False'
    fft_size: fft_size
    history_size: int(round((float(samp_rate)/fft_size)*hist_time))
    lookahead: int(round((float(samp_rate)/fft_size)*lookahead_time))
    max_burst_len: '0'
    max_bursts: '0'
    minoutbuf: 2048*1000
    sample_rate: samp_rate
    threshold: threshold
  states: {}
- name: fhss_utils_fine_burst_measure_0
  id: fhss_utils_fine_burst_measure
  parameters:
    freq_resolution: '4000'
    samples: '2048'
    threshold: '0.5'
  states: {}
- name: fhss_utils_pdu_quadrature_demod_cf_0
  id: fhss_utils_pdu_quadrature_demod_cf
  parameters:
    sensitivity: '1'
    taps: '[1]'
  states: {}
- name: fhss_utils_tagged_burst_to_pdu_0
  id: fhss_utils_tagged_burst_to_pdu
  parameters:
    decimation: decimation
    max_burst_time: max_burst_time
    min_burst_time: min_burst_time
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
    sample_rate: samp_rate
    taps: decim_taps
    threads: '7'
  states: {}
- name: fsk_burst_extractor_hier_0
  id: fsk_burst_extractor_hier
  parameters:
    burst_width: int(500e3)
    center_freq: center_freq
    cfo_bin_resolution: '10000'
    cfo_samps_to_average: '2048'
    decimation: decimation
    fft_size: fft_size
    hist_time: '0.004'
    lookahead_time: '0.0005'
    max_burst_time: '0.5'
    min_burst_time: '0.001'
    output_attenuation: '40'
    output_cutoff: '0.45'
    output_trans_width: '0.05'
    post_burst_time: '0.00015'
    pre_burst_time: '0.00015'
    samp_rate: samp_rate
    threshold: threshold
  states: {state: disabled}
- name: hist_time
  id: parameter
  parameters:
    hide: part
    label: History Time [s]
    type: eng_float
    value: '0.004'
  states: {}
- name: lookahead_time
  id: parameter
  parameters:
    hide: part
    label: Lookahead Time [s]
    type: eng_float
    value: '0.0005'
  states: {}
- name: max_burst_time
  id: parameter
  parameters:
    hide: part
    label: Max Burst Time [s]
    type: eng_float
    value: '0.5'
  states: {}
- name: min_burst_time
  id: parameter
  parameters:
    hide: part
    label: Min Burst Time [s]
    type: eng_float
    value: '0.001'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Burst Detection
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Tuning Parameters
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Input
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  FM Demodulation
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
  states: {}
- name: output_attenuation
  id: parameter
  parameters:
    hide: part
    label: Output Attenuation
    type: eng_float
    value: '40'
  states: {}
- name: output_cutoff
  id: parameter
  parameters:
    hide: part
    label: Output Cutoff [cycles/samp]
    type: eng_float
    value: '0.5'
  states: {}
- name: output_trans_width
  id: parameter
  parameters:
    hide: part
    label: Output Trans. Width [cycles/samp]
    type: eng_float
    value: '0.05'
  states: {}
- name: pdu_utils_pdu_clock_recovery_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: none
  states: {}
- name: pdu_utils_pdu_clock_recovery_0_0
  id: pdu_utils_pdu_clock_recovery
  parameters:
    binary_slice: binary
  states: {}
- name: pdu_utils_pdu_fine_time_measure_0
  id: pdu_utils_pdu_fine_time_measure
  parameters:
    average_width: '10'
    buffer_percent: '15'
    post_burst_time: post_burst_time
    pre_burst_time: pre_burst_time
  states: {}
- name: pdu_utils_pdu_fir_filter_1
  id: pdu_utils_pdu_fir_filter
  parameters:
    decimation: '2'
    taps: fir_taps
  states: {}
- name: pdu_utils_pdu_split_0_0
  id: pdu_utils_pdu_split
  parameters:
    pass_empty: 'False'
  states: {}
- name: post_burst_time
  id: parameter
  parameters:
    hide: part
    label: Post Burst Time [s]
    type: eng_float
    value: '0.00008'
  states: {}
- name: pre_burst_time
  id: parameter
  parameters:
    hide: part
    label: Pre Burst Time [s]
    type: eng_float
    value: '0.00008'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    label1: ''
    name: '"FM Demodulation"'
    size: '102400'
    srate: samp_rate/decimation
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: ''
    marker1: '0'
    name: '"Soft Symbols"'
    size: '102400'
    srate: '1'
    style1: '0'
    tr_delay: '.001'
    tr_level: '0.000001'
    type: msg_float
    update_time: '0.01'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation/2
    fc: '0'
    fftsize: '128'
    gui_hint: 1,0,1,1
    name: '"Burst Spectrogram"'
    showports: 'True'
    type: msg_complex
    update_time: '0.005'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,3
    int_max: '0'
    int_min: '-120'
    name: '"Input Spectrogram"'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    short_id: r
    type: intx
    value: int(30.72e6)
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: 'True'
    minoutbuf: 2048*1000
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: bursts
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: input
  states: {state: disabled}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: bursts
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0_1, '0']
- [blocks_interleaved_short_to_complex_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_0, '0']
- [fhss_utils_fft_burst_tagger_0, '0', fhss_utils_tagged_burst_to_pdu_0, '0']
- [fhss_utils_fine_burst_measure_0, pdu_out, pdu_utils_pdu_fir_filter_1, pdu_in]
- [fhss_utils_pdu_quadrature_demod_cf_0, fpdus, pdu_utils_pdu_clock_recovery_0, pdu_in]
- [fhss_utils_pdu_quadrature_demod_cf_0, fpdus, pdu_utils_pdu_clock_recovery_0_0, pdu_in]
- [fhss_utils_pdu_quadrature_demod_cf_0, fpdus, qtgui_time_sink_x_0_0_0_0_0, in]
- [fhss_utils_tagged_burst_to_pdu_0, cpdus, fhss_utils_fine_burst_measure_0, pdu_in]
- [fsk_burst_extractor_hier_0, pdu_out, virtual_sink_0_0, '0']
- [pdu_utils_pdu_clock_recovery_0, pdu_out, pdu_utils_pdu_split_0_0, pdu_in]
- [pdu_utils_pdu_clock_recovery_0, pdu_out, qtgui_time_sink_x_0_0_0_0_0_0_0_0, in]
- [pdu_utils_pdu_clock_recovery_0_0, pdu_out, virtual_sink_0_0_0, '0']
- [pdu_utils_pdu_fine_time_measure_0, pdu_out, virtual_sink_0_0, '0']
- [pdu_utils_pdu_fir_filter_1, pdu_out, pdu_utils_pdu_fine_time_measure_0, pdu_in]
- [pdu_utils_pdu_split_0_0, dict, blocks_message_debug_0_1, print]
- [uhd_usrp_source_1, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', fhss_utils_fft_burst_tagger_0, '0']
- [virtual_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [virtual_source_0_1, '0', fsk_burst_extractor_hier_0, '0']
- [virtual_source_0_2, '0', fhss_utils_pdu_quadrature_demod_cf_0, cpdus]
- [virtual_source_0_2, '0', qtgui_waterfall_sink_x_0, in]

metadata:
  file_format: 1

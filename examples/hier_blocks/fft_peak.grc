options:
  parameters:
    category: '[Sandia]/FHSS Utilities/GRC Hier Blocks'
    comment: This program finds the peak FFT index of an input dataset
    generate_options: hb
    id: fft_peak
    output_language: python
    title: FFT Peak
  states: {}

blocks:
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: fft_len
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: float
  states: {}
- name: fft_len
  id: parameter
  parameters:
    label: FFT Length
    value: '32'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: max_i
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: fft
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_argmax_xx_0, '0', blocks_repeat_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_argmax_xx_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_vector_to_stream_0, '0']
- [blocks_repeat_0, '0', blocks_short_to_float_0, '0']
- [blocks_short_to_float_0, '0', pad_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_0_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_1, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1

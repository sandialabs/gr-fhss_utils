options:
  parameters:
    author: J. A. Gilbert
    generate_options: qt_gui
    id: testbed_coarse_dehopper
    output_language: python
    title: Coarse Dehopper Testbed
  states: {}

blocks:
- name: file_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Inut File Rate:'
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 20000e3
    value: 12e3
  states: {}
- name: freq_sample_delay_samps
  id: variable
  parameters:
    value: int(freq_SH_delay_syms * samp_per_sym)*0+4233
  states: {}
- name: freq_samps_to_avg
  id: variable
  parameters:
    value: int(freq_syms_to_avg * samp_per_sym)*0+2113
  states: {}
- name: mag_samps_to_avg
  id: variable
  parameters:
    value: mag_syms_to_avg * samp_per_sym
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: input_rate * 1.0  / (fft_len / 2.0) if output_rate == 0 else output_rate
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: input_rate*1.0 / symbol_rate
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Magnitude Threshold
    orient: Qt.Horizontal
    start: '.0001'
    step: '.0001'
    stop: '.1'
    value: '0.008'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(freq_samps_to_avg) + freq_sample_delay_samps
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: coarse_dehopper_output.fc32
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/a.sc16
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: in_file
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Dehopping Mixer
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pow(2,-15)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: input_rate / (2.0 * math.pi * 1e6)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: file_rate
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: '1'
    sensitivity: 2.0 * pi / fft_len
  states: {}
- name: fft_len
  id: parameter
  parameters:
    comment: |-
      FFT length, should be
      relatively small
    label: FFT Size
    short_id: f
    type: intx
    value: '32'
  states: {}
- name: fft_peak_0
  id: fft_peak
  parameters:
    fft_len: fft_len
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Channel Filter
    decim: '2'
    taps: firdes.low_pass_2(1,1,.25,.05,60)
    type: ccc
  states: {}
- name: freq_SH_delay_syms
  id: parameter
  parameters:
    comment: |-
      Additional delay for sample-and-hold
      frequency estimate (delay into burst)
    label: Freq S&H Delay (Syms)
    short_id: d
    type: eng_float
    value: '32'
  states: {}
- name: freq_syms_to_avg
  id: parameter
  parameters:
    comment: |-
      Number of symbols to average
      the frequency estimate over
    label: Freq Avg Length (Syms)
    short_id: a
    type: eng_float
    value: 24*4
  states: {}
- name: import
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: in
  id: virtual_sink
  parameters:
    stream_id: in
  states: {}
- name: in_0
  id: virtual_sink
  parameters:
    stream_id: argmax
  states: {}
- name: in_0_0
  id: virtual_sink
  parameters:
    stream_id: fft
  states: {}
- name: in_file
  id: parameter
  parameters:
    comment: |-
      The input file to process, should be
      in complex floating point format
    label: Input File
    short_id: I
    value: /tmp/a.sc16
  states: {}
- name: input_rate
  id: parameter
  parameters:
    comment: |-
      Sample rate of the input
      file in Hz
    label: Input Sample Rate
    short_id: i
    type: eng_float
    value: 30e6
  states: {}
- name: mag_syms_to_avg
  id: parameter
  parameters:
    comment: |-
      Number of symbols to average
      the magnitude estimate over
    label: Mag Avg Length (Syms)
    short_id: A
    type: eng_float
    value: '4'
  states: {}
- name: output_rate
  id: parameter
  parameters:
    comment: |-
      Desired output sample rate, if left as zero the 
      output rate will default to input_rate / (fft_size/2)
    label: Output Sample Rate
    short_id: o
    type: eng_float
    value: '0'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: Resampler
    nfilts: '32'
    rrate: 1.0 * out_rate / (0.5 * input_rate)
    type: ccf
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_rate
    fc: '0'
    fftsize: '8192'
    gui_hint: 1,0,1,2
    label1: Input
    label2: Dehopped
    label3: Mixer LO
    nconnections: '3'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: t@0:3,1,1,1
    label1: Magnitude
    label2: FM Demod
    nconnections: '2'
    size: '10240'
    srate: '1'
    tr_delay: '1024'
    tr_level: '0.12'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '.25'
    ymin: '-.25'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: t@1:1,0,1,1
    label1: mag
    label2: thresh
    label3: s&h
    label4: avg
    label5: ''
    nconnections: '5'
    size: 2000000*5
    srate: '1'
    tr_delay: '.002'
    tr_level: '0.005'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: t@0:2,1,1,1
    label1: Dehop Freq
    size: int(102400/4)
    srate: '1'
    tr_delay: '.002'
    tr_level: '0.005'
    type: float
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: t@2:0,0,1,1
    label1: Frequency
    size: '10240'
    srate: '1'
    tr_delay: '1024'
    tr_level: '0.12'
    type: float
    ymax: '.25'
    ymin: '-.25'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: t@2:1,0,1,1
    label1: FFT
    size: int(fft_len)
    srate: '1'
    tr_delay: '1024'
    tr_level: '0.12'
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: t@1:0,0,1,1
    name: '"Dehopped Spectrogram"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: t@0:2,0,3,1
    name: '"Output Spectrogram"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rs
  id: virtual_sink
  parameters:
    stream_id: resampled
  states: {}
- name: rs_0
  id: virtual_sink
  parameters:
    stream_id: dehopped
  states: {}
- name: rs_0_0
  id: virtual_sink
  parameters:
    stream_id: inst_f
  states: {}
- name: rs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: m_avg
  states: {}
- name: rs_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: m_t
  states: {}
- name: rs_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: s_h
  states: {}
- name: rs_0_1_0
  id: virtual_sink
  parameters:
    stream_id: vco
  states: {}
- name: s_and_h_detector_0
  id: s_and_h_detector
  parameters:
    comment: Amplitude / Frequency Detector
    freq_sample_delay_samps: freq_sample_delay_samps
    freq_samps_to_avg: freq_samps_to_avg
    mag_samps_to_avg: int(mag_samps_to_avg)
    thresh: thresh
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    comment: |-
      Approximate baseband
      data symbol rate
    label: Symbol Rate
    short_id: r
    type: eng_float
    value: 64e3
  states: {}
- name: t
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: Output
    label1: Debug
    label2: FFT
    num_tabs: '3'
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: qd
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: argmax
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: in
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: vco
  states: {}
- name: virtual_source_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: in
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: fft
  states: {}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: inst_f
  states: {}
- name: virtual_source_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: m_avg
  states: {}
- name: virtual_source_0_0_2_1
  id: virtual_source
  parameters:
    stream_id: s_h
  states: {}
- name: virtual_source_0_0_2_1_0
  id: virtual_source
  parameters:
    stream_id: m_t
  states: {}
- name: virtual_source_0_0_2_1_1
  id: virtual_source
  parameters:
    stream_id: s_h
  states: {}
- name: virtual_source_0_0_2_2
  id: virtual_source
  parameters:
    stream_id: vco
  states: {}
- name: virtual_source_0_0_2_2_0
  id: virtual_source
  parameters:
    stream_id: s_h
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: resampled
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: qd
  states: {}
- name: virtual_source_0_1_2
  id: virtual_source
  parameters:
    stream_id: resampled
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: dehopped
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '4']
- [analog_quadrature_demod_cf_0_0, '0', blocks_null_sink_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', virtual_sink_1_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', s_and_h_detector_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_moving_average_xx_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', rs_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_throttle_0, '0', fft_peak_0, '0']
- [blocks_throttle_0, '0', in, '0']
- [blocks_vco_c_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_vco_c_0, '0', rs_0_1_0, '0']
- [fft_peak_0, '0', in_0, '0']
- [fft_peak_0, '0', s_and_h_detector_0, '1']
- [fft_peak_0, '1', in_0_0, '0']
- [fir_filter_xxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', rs, '0']
- [s_and_h_detector_0, '0', rs_0_0_0_0_0, '0']
- [s_and_h_detector_0, '1', rs_0_0, '0']
- [s_and_h_detector_0, '2', rs_0_0_0_0, '0']
- [s_and_h_detector_0, '3', rs_0_0_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [virtual_source_0_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_freq_sink_x_0_0, '2']
- [virtual_source_0_0_0_2, '0', blocks_delay_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [virtual_source_0_0_2, '0', qtgui_time_sink_x_0_0, '3']
- [virtual_source_0_0_2_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [virtual_source_0_0_2_1, '0', qtgui_time_sink_x_0_0, '2']
- [virtual_source_0_0_2_1_0, '0', qtgui_time_sink_x_0_0, '1']
- [virtual_source_0_0_2_1_1, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_0_0_2_2, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_0_0_2_2_0, '0', blocks_vco_c_0, '0']
- [virtual_source_0_1, '0', blocks_complex_to_mag_0, '0']
- [virtual_source_0_1_1, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_1_2, '0', analog_quadrature_demod_cf_0_0, '0']
- [virtual_source_0_1_2, '0', blocks_file_sink_0_0, '0']
- [virtual_source_0_1_2, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [virtual_source_0_2_0, '0', qtgui_freq_sink_x_0_0, '1']
- [virtual_source_0_2_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1

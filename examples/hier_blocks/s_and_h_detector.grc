<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>s_and_h_detector</value></param>
<param><key>category</key><value>[Sandia]/FHSS Utilities/GRC Hier Blocks</value></param>
<param><key>comment</key><value>This block takes a frequency and magnitude input, applies moving averages, waits for a particular threshold and sample / holds the frequency estimate.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Sample and Hold Detector</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>int(freq_samps_to_avg - mag_samps_to_avg + freq_sample_delay_samps)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>int(freq_samps_to_avg)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0 / (freq_samps_to_avg)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>int(mag_samps_to_avg)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0 / (mag_samps_to_avg)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sample_and_hold_xx</key>
<param><key>id</key><value>blocks_sample_and_hold_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>thresh</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>thresh/4.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_sample_delay_samps</value></param>
<param><key>label</key><value>Freq S&amp;H Delay</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_samps_to_avg</value></param>
<param><key>label</key><value>Freq Avg Samples</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mag_samps_to_avg</value></param>
<param><key>label</key><value>Mag Avg Samples</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>inst_f</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>m_t</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>m_avg</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>mag</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>thresh</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>timing_utils_edge_detector_bb</key>
<param><key>id</key><value>timing_utils_edge_detector_bb_0</value></param>
<param><key>mode</key><value>timing_utils.RISING_EDGE</value></param>
</block>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>timing_utils_edge_detector_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>pad_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sample_and_hold_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>timing_utils_edge_detector_bb_0</source_block_id><sink_block_id>blocks_sample_and_hold_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>

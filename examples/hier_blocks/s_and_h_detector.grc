options:
  parameters:
    category: '[Sandia]/FHSS Utilities/GRC Hier Blocks'
    comment: This block takes a frequency and magnitude input, applies moving averages, waits for a particular threshold and sample / holds the frequency estimate.
    generate_options: hb
    id: s_and_h_detector
    output_language: python
    title: Sample and Hold Detector
  states: {}

blocks:
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(freq_samps_to_avg - mag_samps_to_avg + freq_sample_delay_samps)
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: int(freq_samps_to_avg)
    max_iter: '4000'
    scale: 1.0 / (freq_samps_to_avg)
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(mag_samps_to_avg)
    max_iter: '4000'
    scale: 1.0 / (mag_samps_to_avg)
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh
    init: '0'
    low: thresh/4.0
  states: {}
- name: freq_sample_delay_samps
  id: parameter
  parameters:
    label: Freq S&H Delay
    type: intx
    value: '128'
  states: {}
- name: freq_samps_to_avg
  id: parameter
  parameters:
    label: Freq Avg Samples
    type: intx
    value: '128'
  states: {}
- name: mag_samps_to_avg
  id: parameter
  parameters:
    label: Mag Avg Samples
    type: intx
    value: '128'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: inst_f
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: m_t
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: m_avg
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: mag
    type: float
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: freq
    type: float
  states: {}
- name: thresh
  id: parameter
  parameters:
    label: Threshold
    type: eng_float
    value: '0.005'
  states: {}
- name: timing_utils_edge_detector_bb_0
  id: timing_utils_edge_detector_bb
  parameters:
    mode: timing_utils.RISING_EDGE
  states: {}

connections:
- [blocks_delay_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_float_to_char_0, '0', timing_utils_edge_detector_bb_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sample_and_hold_xx_0, '0']
- [blocks_moving_average_xx_0, '0', pad_sink_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', pad_sink_0_0_1, '0']
- [blocks_sample_and_hold_xx_0, '0', pad_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0, '0', pad_sink_0_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']
- [pad_source_0_0, '0', blocks_moving_average_xx_0, '0']
- [timing_utils_edge_detector_bb_0, '0', blocks_sample_and_hold_xx_0, '1']

metadata:
  file_format: 1

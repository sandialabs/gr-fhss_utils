<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fine_dehopper</value></param>
<param><key>category</key><value>[Sandia]/FHSS Utilities/GRC Hier Blocks</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Fine Dehopper</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bias</value></param>
<param><key>label</key><value>Bit Bias</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-1.0 * bias * (resamp_rate)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>int(freq_samps_to_avg) + freq_sample_delay_samps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0</value></param>
<param><key>comment</key><value>Dehopping Mixer</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>sensitivity</key><value>1</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>comment</key><value>Channel Filter</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1,1,.25,.05,60)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_sample_delay_samps</value></param>
<param><key>label</key><value>Freq S&amp;H Delay</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_samps_to_avg</value></param>
<param><key>label</key><value>Freq Avg Samples</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>in</value></param>
<param><key>stream_id</key><value>in</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mag_samps_to_avg</value></param>
<param><key>label</key><value>Mag Avg Samples</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>comment</key><value>Resampler</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>resamp_rate * 2.0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>resamp_rate</value></param>
<param><key>label</key><value>Resampler Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.125</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>rs_0</value></param>
<param><key>stream_id</key><value>dehopped</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>rs_0_0</value></param>
<param><key>stream_id</key><value>inst_f</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>rs_0_0_0</value></param>
<param><key>stream_id</key><value>m_avg</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>rs_0_0_0_0</value></param>
<param><key>stream_id</key><value>m_t</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>rs_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>s_h</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>rs_0_1_0</value></param>
<param><key>stream_id</key><value>vco</value></param>
</block>
<block>
<key>s_and_h_detector</key>
<param><key>id</key><value>s_and_h_detector_0</value></param>
<param><key>comment</key><value>Amplitude / Frequency Detector</value></param>
<param><key>freq_samps_to_avg</key><value>freq_samps_to_avg</value></param>
<param><key>freq_sample_delay_samps</key><value>freq_sample_delay_samps</value></param>
<param><key>mag_samps_to_avg</key><value>mag_samps_to_avg</value></param>
<param><key>thresh</key><value>thresh</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>thresh</value></param>
<param><key>label</key><value>Threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.005</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_2</value></param>
<param><key>stream_id</key><value>in</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_2_2_0</value></param>
<param><key>stream_id</key><value>s_h</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>s_and_h_detector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>rs_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>s_and_h_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0</source_block_id><sink_block_id>rs_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>rs_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>in</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s_and_h_detector_0</source_block_id><sink_block_id>rs_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s_and_h_detector_0</source_block_id><sink_block_id>rs_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s_and_h_detector_0</source_block_id><sink_block_id>rs_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>s_and_h_detector_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_2</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_2_2_0</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

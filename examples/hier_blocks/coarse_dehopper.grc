options:
  parameters:
    category: '[Sandia]/FHSS Utilities/GRC Hier Blocks'
    generate_options: hb
    id: coarse_dehopper_grc
    output_language: python
    title: Coarse Dehopper GRC
  states: {}

blocks:
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(freq_samps_to_avg) + freq_sample_delay_samps
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Dehopping Mixer
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: '1'
    sensitivity: 2.0 * pi / fft_len
  states: {}
- name: fft_len
  id: parameter
  parameters:
    label: FFT Length
    type: intx
    value: '32'
  states: {}
- name: fft_peak_0
  id: fft_peak
  parameters:
    fft_len: fft_len
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Channel Filter
    decim: '2'
    taps: firdes.low_pass_2(1,1,.30,.05,60)
    type: ccc
  states: {}
- name: freq_sample_delay_samps
  id: parameter
  parameters:
    label: Freq S&H Delay
    type: intx
    value: '128'
  states: {}
- name: freq_samps_to_avg
  id: parameter
  parameters:
    label: Freq Avg Samples
    type: intx
    value: '128'
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: in
  id: virtual_sink
  parameters:
    stream_id: in
  states: {}
- name: in_0
  id: virtual_sink
  parameters:
    stream_id: argmax
  states: {}
- name: mag_samps_to_avg
  id: parameter
  parameters:
    label: Mag Avg Samples
    type: intx
    value: '128'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: inst_f
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: m_t
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: m_avg
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: s_h
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: Resampler
    nfilts: '32'
    rrate: 1.0 / (fft_len / 4.0)
    type: ccf
  states: {}
- name: rs_0
  id: virtual_sink
  parameters:
    stream_id: dehopped
  states: {}
- name: rs_0_0
  id: virtual_sink
  parameters:
    stream_id: inst_f
  states: {}
- name: rs_0_0_0
  id: virtual_sink
  parameters:
    stream_id: m_avg
  states: {}
- name: rs_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: m_t
  states: {}
- name: rs_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: s_h
  states: {}
- name: rs_0_1_0
  id: virtual_sink
  parameters:
    stream_id: vco
  states: {}
- name: s_and_h_detector_0
  id: s_and_h_detector
  parameters:
    comment: Amplitude / Frequency Detector
    freq_sample_delay_samps: freq_sample_delay_samps
    freq_samps_to_avg: freq_samps_to_avg
    mag_samps_to_avg: mag_samps_to_avg
    thresh: thresh
  states: {}
- name: thresh
  id: parameter
  parameters:
    label: Threshold
    type: eng_float
    value: '0.005'
  states: {}
- name: virtual_source_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: in
  states: {}
- name: virtual_source_0_0_2_2_0
  id: virtual_source
  parameters:
    stream_id: s_h
  states: {}
- name: virtual_source_0_0_2_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: m_avg
  states: {}
- name: virtual_source_0_0_2_2_0_0_1
  id: virtual_source
  parameters:
    stream_id: m_t
  states: {}
- name: virtual_source_0_0_2_2_0_0_2
  id: virtual_source
  parameters:
    stream_id: inst_f
  states: {}
- name: virtual_source_0_0_2_2_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: s_h
  states: {}

connections:
- [blocks_complex_to_mag_0_0, '0', s_and_h_detector_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', rs_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_vco_c_0, '0', rs_0_1_0, '0']
- [fft_peak_0, '0', in_0, '0']
- [fft_peak_0, '0', s_and_h_detector_0, '1']
- [fir_filter_xxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_0_0, '0']
- [pad_source_0, '0', fft_peak_0, '0']
- [pad_source_0, '0', in, '0']
- [pfb_arb_resampler_xxx_0, '0', pad_sink_0, '0']
- [s_and_h_detector_0, '0', rs_0_0, '0']
- [s_and_h_detector_0, '1', rs_0_0_0, '0']
- [s_and_h_detector_0, '2', rs_0_0_0_0, '0']
- [s_and_h_detector_0, '3', rs_0_0_0_0_0, '0']
- [virtual_source_0_0_0_2, '0', blocks_delay_0_0, '0']
- [virtual_source_0_0_2_2_0, '0', blocks_vco_c_0, '0']
- [virtual_source_0_0_2_2_0_0_0, '0', pad_sink_0_0_0_0, '0']
- [virtual_source_0_0_2_2_0_0_1, '0', pad_sink_0_0_0, '0']
- [virtual_source_0_0_2_2_0_0_2, '0', pad_sink_0_0, '0']
- [virtual_source_0_0_2_2_0_0_2_0, '0', pad_sink_0_0_1, '0']

metadata:
  file_format: 1

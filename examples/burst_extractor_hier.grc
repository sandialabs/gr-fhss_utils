options:
  parameters:
    generate_options: hb
    id: fsk_burst_extractor_hier_autogen
    output_language: python
    title: FSK Burst Extractor Hier
  states: {}

blocks:
- name: burst_width
  id: parameter
  parameters:
    hide: part
    label: Burst Width [Hz]
    type: intx
    value: int(500e3)
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Center Frequency [Hz]
    type: eng_float
    value: 915e6
  states: {}
- name: cfo_start_offset
  id: parameter
  parameters:
    label: CFO Start Offset [s]
    type: eng_float
    value: '0'
  states: {}
- name: cfo_threshold
  id: parameter
  parameters:
    label: CFO threshold
    type: eng_float
    value: '0.5'
  states: {}
- name: cfo_time_to_average
  id: parameter
  parameters:
    label: CFO Average Time [s]
    type: eng_float
    value: '0.0005'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '32'
  states: {}
- name: fft_size
  id: parameter
  parameters:
    label: FFT Size
    type: intx
    value: '256'
  states: {}
- name: fhss_utils_burst_downmix_0
  id: fhss_utils_burst_downmix
  parameters:
    decimation: int(decimation/2)
    taps: firdes.low_pass_2(1, 1, 0.5/(decimation/2), 0.05/(decimation/2), 40)
  states: {}
- name: fhss_utils_burst_measure_0
  id: fhss_utils_burst_measure
  parameters: {}
  states: {}
- name: fhss_utils_fft_burst_tagger_0
  id: fhss_utils_fft_burst_tagger
  parameters:
    burst_post_len: int(round((float(samp_rate)/fft_size)*post_burst_time))
    burst_pre_len: int(round((float(samp_rate)/fft_size)*pre_burst_time))
    burst_width: burst_width
    center_frequency: center_freq
    debug: 'False'
    fft_size: fft_size
    history_size: int(round((float(samp_rate)/fft_size)*hist_time))
    lookahead: int(round((float(samp_rate)/fft_size)*lookahead_time))
    max_burst_len: '0'
    max_bursts: '0'
    minoutbuf: 2048*1000
    sample_rate: samp_rate
    threshold: threshold
  states: {}
- name: fhss_utils_fsk_cfo_estimate_0
  id: fhss_utils_fsk_cfo_estimate
  parameters:
    samples_to_average: int(round(cfo_time_to_average*samp_rate*2/decimation))
    search_depth: int(round(samp_rate*pre_burst_time)*2)
    start_finder_taps: firdes.low_pass_2(1, 1, 0.1, 0.1, 40)
    start_offset: int(round(cfo_start_offset*samp_rate*2/decimation))
    threshold: cfo_threshold
  states: {}
- name: fhss_utils_tagged_burst_to_pdu_0
  id: fhss_utils_tagged_burst_to_pdu
  parameters:
    decimation: '16'
    max_burst_time: '.5'
    min_burst_time: '.003'
    relative_center_frequency: '0.0'
    relative_sample_rate: '1.0'
    relative_span: '1.0'
    sample_rate: 16e6
    taps: ''
    threads: '3'
  states: {}
- name: hist_time
  id: parameter
  parameters:
    hide: part
    label: History Time [s]
    type: eng_float
    value: '0.004'
  states: {}
- name: lookahead_time
  id: parameter
  parameters:
    hide: part
    label: Lookahead Time [s]
    type: eng_float
    value: '0.0005'
  states: {}
- name: max_burst_time
  id: parameter
  parameters:
    hide: part
    label: Max Burst Time [s]
    type: eng_float
    value: '0.5'
  states: {}
- name: max_nmsgs
  id: parameter
  parameters:
    hide: part
    label: Max nmsgs
    type: intx
    value: '50'
  states: {}
- name: min_burst_time
  id: parameter
  parameters:
    hide: part
    label: Min Burst Time [s]
    type: eng_float
    value: '0.001'
  states: {}
- name: output_attenuation
  id: parameter
  parameters:
    hide: part
    label: Output Attenuation
    type: eng_float
    value: '40'
  states: {}
- name: output_cutoff
  id: parameter
  parameters:
    hide: part
    label: Output Cutoff [cycles/samp]
    type: eng_float
    value: '0.5'
  states: {}
- name: output_trans_width
  id: parameter
  parameters:
    hide: part
    label: Output Trans. Width [cycles/samp]
    type: eng_float
    value: '0.05'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pdu_out
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_utils_pdu_fir_filter_1
  id: pdu_utils_pdu_fir_filter
  parameters:
    decimation: '2'
    taps: firdes.low_pass_2(1, 1, 0.5*output_cutoff, 0.5*output_trans_width, output_attenuation)
  states: {}
- name: pdu_utils_pdu_flow_ctrl_0
  id: pdu_utils_pdu_flow_ctrl
  parameters:
    block0: fhss_utils_burst_downmix_0
    block1: fhss_utils_fsk_cfo_estimate_0
    block10: ''
    block11: ''
    block12: ''
    block13: ''
    block14: ''
    block2: pdu_utils_pdu_fir_filter_1
    block3: fhss_utils_burst_measure_0
    block4: ''
    block5: ''
    block6: ''
    block7: ''
    block8: ''
    block9: ''
    max_nmsgs: max_nmsgs
    nblocks: '4'
    verbose: 'False'
  states: {}
- name: post_burst_time
  id: parameter
  parameters:
    hide: part
    label: Post Burst Time [s]
    type: eng_float
    value: '0.00008'
  states: {}
- name: pre_burst_time
  id: parameter
  parameters:
    hide: part
    label: Pre Burst Time [s]
    type: eng_float
    value: '0.00008'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate [Hz]
    type: intx
    value: int(16e6)
  states: {}
- name: threshold
  id: parameter
  parameters:
    label: Threshold [dB]
    type: eng_float
    value: '6'
  states: {}

connections:
- [fhss_utils_burst_downmix_0, cpdus, fhss_utils_fsk_cfo_estimate_0, pdu_in]
- [fhss_utils_burst_measure_0, cpdus, pad_sink_0, in]
- [fhss_utils_fft_burst_tagger_0, '0', fhss_utils_tagged_burst_to_pdu_0, '0']
- [fhss_utils_fsk_cfo_estimate_0, pdu_out, pdu_utils_pdu_fir_filter_1, pdu_in]
- [fhss_utils_tagged_burst_to_pdu_0, cpdus, pdu_utils_pdu_flow_ctrl_0, pdu_in]
- [pad_source_0, '0', fhss_utils_fft_burst_tagger_0, '0']
- [pdu_utils_pdu_fir_filter_1, pdu_out, fhss_utils_burst_measure_0, cpdus]
- [pdu_utils_pdu_flow_ctrl_0, pdu_out, fhss_utils_burst_downmix_0, cpdus]

metadata:
  file_format: 1

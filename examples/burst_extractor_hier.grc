<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_burst_extractor_hier_autogen</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>FSK Burst Extractor Hier</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>burst_width</value></param>
<param><key>label</key><value>Burst Width [Hz]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(500e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value>Center Frequency [Hz]</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_start_offset</value></param>
<param><key>label</key><value>CFO Start Offset [s]</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_threshold</value></param>
<param><key>label</key><value>CFO threshold</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_time_to_average</value></param>
<param><key>label</key><value>CFO Average Time [s]</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimation</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>fhss_utils_burst_downmix</key>
<param><key>id</key><value>fhss_utils_burst_downmix_0</value></param>
<param><key>decimation</key><value>decimation/2</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1, 1, 0.5/(decimation/2), 0.05/(decimation/2), 40)</value></param>
</block>
<block>
<key>fhss_utils_burst_measure</key>
<param><key>id</key><value>fhss_utils_burst_measure_0</value></param>
</block>
<block>
<key>fhss_utils_fft_burst_tagger</key>
<param><key>id</key><value>fhss_utils_fft_burst_tagger_0</value></param>
<param><key>burst_width</key><value>burst_width</value></param>
<param><key>center_frequency</key><value>center_freq</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>history_size</key><value>int(round((float(samp_rate)/fft_size)*hist_time))</value></param>
<param><key>lookahead</key><value>int(round((float(samp_rate)/fft_size)*lookahead_time))</value></param>
<param><key>max_burst_len</key><value>0</value></param>
<param><key>max_bursts</key><value>0</value></param>
<param><key>minoutbuf</key><value>2048*1000</value></param>
<param><key>burst_post_len</key><value>int(round((float(samp_rate)/fft_size)*post_burst_time))</value></param>
<param><key>burst_pre_len</key><value>int(round((float(samp_rate)/fft_size)*pre_burst_time))</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>fhss_utils_fsk_cfo_estimate</key>
<param><key>id</key><value>fhss_utils_fsk_cfo_estimate_0</value></param>
<param><key>samples_to_average</key><value>int(round(cfo_time_to_average*samp_rate*2/decimation))</value></param>
<param><key>search_depth</key><value>int(round(samp_rate*pre_burst_time)*2)</value></param>
<param><key>start_finder_taps</key><value>firdes.low_pass_2(1, 1, 0.1, 0.1, 40)</value></param>
<param><key>start_offset</key><value>int(round(cfo_start_offset*samp_rate*2/decimation))</value></param>
<param><key>threshold</key><value>cfo_threshold</value></param>
</block>
<block>
<key>fhss_utils_tagged_burst_to_pdu</key>
<param><key>id</key><value>fhss_utils_tagged_burst_to_pdu_0</value></param>
<param><key>decimation</key><value>16</value></param>
<param><key>taps</key><value></value></param>
<param><key>max_burst_time</key><value>.5</value></param>
<param><key>min_burst_time</key><value>.003</value></param>
<param><key>threads</key><value>3</value></param>
<param><key>relative_center_frequency</key><value>0.0</value></param>
<param><key>relative_sample_rate</key><value>1.0</value></param>
<param><key>relative_span</key><value>1.0</value></param>
<param><key>sample_rate</key><value>16e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hist_time</value></param>
<param><key>label</key><value>History Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.004</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lookahead_time</value></param>
<param><key>label</key><value>Lookahead Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_burst_time</value></param>
<param><key>label</key><value>Max Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_nmsgs</value></param>
<param><key>label</key><value>Max nmsgs</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>min_burst_time</value></param>
<param><key>label</key><value>Min Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_attenuation</value></param>
<param><key>label</key><value>Output Attenuation</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_cutoff</value></param>
<param><key>label</key><value>Output Cutoff [cycles/samp]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_trans_width</value></param>
<param><key>label</key><value>Output Trans. Width [cycles/samp]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>pdu_out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pdu_utils_pdu_fir_filter</key>
<param><key>id</key><value>pdu_utils_pdu_fir_filter_1</value></param>
<param><key>decimation</key><value>2</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1, 1, 0.5*output_cutoff, 0.5*output_trans_width, output_attenuation)</value></param>
</block>
<block>
<key>pdu_utils_pdu_flow_ctrl</key>
<param><key>id</key><value>pdu_utils_pdu_flow_ctrl_0</value></param>
<param><key>block0</key><value>fhss_utils_burst_downmix_0</value></param>
<param><key>block1</key><value>fhss_utils_fsk_cfo_estimate_0</value></param>
<param><key>block10</key><value></value></param>
<param><key>block11</key><value></value></param>
<param><key>block12</key><value></value></param>
<param><key>block13</key><value></value></param>
<param><key>block14</key><value></value></param>
<param><key>block2</key><value>pdu_utils_pdu_fir_filter_1</value></param>
<param><key>block3</key><value>fhss_utils_burst_measure_0</value></param>
<param><key>block4</key><value></value></param>
<param><key>block5</key><value></value></param>
<param><key>block6</key><value></value></param>
<param><key>block7</key><value></value></param>
<param><key>block8</key><value></value></param>
<param><key>block9</key><value></value></param>
<param><key>max_nmsgs</key><value>max_nmsgs</value></param>
<param><key>nblocks</key><value>4</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>post_burst_time</value></param>
<param><key>label</key><value>Post Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.00008</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_burst_time</value></param>
<param><key>label</key><value>Pre Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.00008</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate [Hz]</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(16e6)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold [dB]</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6</value></param>
</block>
<connection><source_block_id>fhss_utils_burst_downmix_0</source_block_id><sink_block_id>fhss_utils_fsk_cfo_estimate_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>fhss_utils_burst_measure_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>cpdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fhss_utils_fft_burst_tagger_0</source_block_id><sink_block_id>fhss_utils_tagged_burst_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fhss_utils_fsk_cfo_estimate_0</source_block_id><sink_block_id>pdu_utils_pdu_fir_filter_1</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>fhss_utils_tagged_burst_to_pdu_0</source_block_id><sink_block_id>pdu_utils_pdu_flow_ctrl_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fhss_utils_fft_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_fir_filter_1</source_block_id><sink_block_id>fhss_utils_burst_measure_0</sink_block_id><source_key>pdu_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_flow_ctrl_0</source_block_id><sink_block_id>fhss_utils_burst_downmix_0</sink_block_id><source_key>pdu_out</source_key><sink_key>cpdus</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fsk_burst_extractor_nohier</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FSK Burst Extractor Hier</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1, 1, output_cutoff/decimation, output_trans_width/decimation, output_attenuation)</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>2048*1000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>burst_width</value></param>
<param><key>label</key><value>Burst Width [Hz]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(500e3)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value>Center Frequency [Hz]</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_bin_resolution</value></param>
<param><key>label</key><value>cfo_bin_resolution</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfo_samps_to_average</value></param>
<param><key>label</key><value>cfo_samps_to_average</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimation</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>fhss_utils_fft_burst_tagger</key>
<param><key>id</key><value>fhss_utils_fft_burst_tagger_0</value></param>
<param><key>burst_width</key><value>burst_width</value></param>
<param><key>center_frequency</key><value>center_freq</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>history_size</key><value>int(round((float(samp_rate)/fft_size)*hist_time))</value></param>
<param><key>lookahead</key><value>int(round((float(samp_rate)/fft_size)*lookahead_time))</value></param>
<param><key>max_burst_len</key><value>0</value></param>
<param><key>max_bursts</key><value>0</value></param>
<param><key>minoutbuf</key><value>2048*1000</value></param>
<param><key>burst_post_len</key><value>int(round((float(samp_rate)/fft_size)*post_burst_time))</value></param>
<param><key>burst_pre_len</key><value>int(round((float(samp_rate)/fft_size)*pre_burst_time))</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>fhss_utils_fine_burst_measure</key>
<param><key>id</key><value>fhss_utils_fine_burst_measure_0</value></param>
<param><key>samples</key><value>cfo_samps_to_average</value></param>
<param><key>freq_resolution</key><value>cfo_bin_resolution</value></param>
<param><key>threshold</key><value>0.5</value></param>
</block>
<block>
<key>fhss_utils_tagged_burst_to_pdu</key>
<param><key>id</key><value>fhss_utils_tagged_burst_to_pdu_0</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>max_burst_time</key><value>max_burst_time</value></param>
<param><key>min_burst_time</key><value>min_burst_time</value></param>
<param><key>threads</key><value>3</value></param>
<param><key>relative_center_frequency</key><value>0.0</value></param>
<param><key>relative_sample_rate</key><value>1.0</value></param>
<param><key>relative_span</key><value>1.0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hist_time</value></param>
<param><key>label</key><value>History Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.004</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lookahead_time</value></param>
<param><key>label</key><value>Lookahead Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_burst_time</value></param>
<param><key>label</key><value>Max Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>min_burst_time</value></param>
<param><key>label</key><value>Min Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_attenuation</value></param>
<param><key>label</key><value>Output Attenuation</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_cutoff</value></param>
<param><key>label</key><value>Output Cutoff</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.26</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_trans_width</value></param>
<param><key>label</key><value>Output Trans. Width</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.4</value></param>
</block>
<block>
<key>pdu_utils_pdu_fine_time_measure</key>
<param><key>id</key><value>pdu_utils_pdu_fine_time_measure_0</value></param>
<param><key>buffer_percent</key><value>15</value></param>
<param><key>average_width</key><value>10</value></param>
<param><key>post_burst_time</key><value>post_burst_time</value></param>
<param><key>pre_burst_time</key><value>pre_burst_time</value></param>
</block>
<block>
<key>pdu_utils_pdu_fir_filter</key>
<param><key>id</key><value>pdu_utils_pdu_fir_filter_1</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1, 1, .25, .1, output_attenuation)</value></param>
</block>
<block>
<key>pdu_utils_pdu_split</key>
<param><key>id</key><value>pdu_utils_pdu_split_0</value></param>
<param><key>pass_empty</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>post_burst_time</value></param>
<param><key>label</key><value>Post Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.00008</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_burst_time</value></param>
<param><key>label</key><value>Pre Burst Time [s]</value></param>
<param><key>hide</key><value>part</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.00008</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.002</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>128</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>update_time</key><value>0.002</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate [Hz]</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>int(16e6)</value></param>
</block>
<block>
<key>sidekiq_snl_sidekiq_source</key>
<param><key>id</key><value>sidekiq_snl_sidekiq_source_0</value></param>
<param><key>adc_rate</key><value>samp_rate</value></param>
<param><key>agc_enabled0</key><value>False</value></param>
<param><key>agc_enabled1</key><value>False</value></param>
<param><key>ant0</key><value>"A1"</value></param>
<param><key>ant1</key><value>"A1"</value></param>
<param><key>dsp_freq0</key><value>0</value></param>
<param><key>dec_factor0</key><value>1</value></param>
<param><key>type0</key><value>fc32</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>dsp_freq1</key><value>0</value></param>
<param><key>dec_factor1</key><value>1</value></param>
<param><key>type1</key><value>fc32</value></param>
<param><key>gain1</key><value>76</value></param>
<param><key>dc_offset_corr0</key><value>False</value></param>
<param><key>dc_offset_corr1</key><value>False</value></param>
<param><key>dev_args</key><value></value></param>
<param><key>lo_freq</key><value>center_freq</value></param>
<param><key>mode</key><value>sidekiq_snl.high_tput</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>bandwidth</key><value>0</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Threshold [dB]</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>fhss_utils_fft_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fhss_utils_fft_burst_tagger_0</source_block_id><sink_block_id>fhss_utils_tagged_burst_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fhss_utils_fine_burst_measure_0</source_block_id><sink_block_id>pdu_utils_pdu_fir_filter_1</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>fhss_utils_tagged_burst_to_pdu_0</source_block_id><sink_block_id>fhss_utils_fine_burst_measure_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_fine_time_measure_0</source_block_id><sink_block_id>pdu_utils_pdu_split_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_fine_time_measure_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>pdu_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_fir_filter_1</source_block_id><sink_block_id>pdu_utils_pdu_fine_time_measure_0</sink_block_id><source_key>pdu_out</source_key><sink_key>pdu_in</sink_key></connection>
<connection><source_block_id>pdu_utils_pdu_split_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>dict</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>sidekiq_snl_sidekiq_source_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sidekiq_snl_sidekiq_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
